IMAGE_INSTALL += "\
    packagegroup-yextra \
"
 
